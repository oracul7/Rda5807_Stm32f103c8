# Keil uVision project Project.uvprojx, settings and files
target Proect (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\User;.\User\Inc;.\CMSIS;.\CMSIS\CM3\CoreSupport;.\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;.\StdPeriph;.\StdPeriph\inc;.\Reales;.\Reales\SPI\Inc;.\Reales\PORTS_DEFINITION;.\Reales\PORTS_DEFINITION\Inc;.\Reales\PCD8544;.\Reales\PCD8544\Inc;.\Reales\PWM;.\Reales\PWM\Inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./User/Src/: main.c
    ./User/Inc/: main.h
  group Startup
    ./CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group CMSIS
    ./CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h system_stm32f10x.c
  group StdPeriph
    ./StdPeriph/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ./StdPeriph/: stm32f10x_conf.h
  group PCD8544
    ./Reales/PCD8544/Inc/: font.h PCD8544.h
    ./Reales/PCD8544/Src/: PCD8544.c
  group SPI
    ./Reales/SPI/Src/: spi.c
    ./Reales/SPI/Inc/: spi.h
  group PORTS_DEFINITION
    ./Reales/PORTS_DEFINITION/Inc/: ports_definition.h
    ./Reales/PORTS_DEFINITION/Src/: ports_definition.c
  group PWM
    ./Reales/PWM/Src/: PWM.c
